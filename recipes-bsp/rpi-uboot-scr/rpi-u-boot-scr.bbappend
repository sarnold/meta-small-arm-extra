FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

COMPATIBLE = "raspberrypi raspberrypi3 raspberrypi3-64"
