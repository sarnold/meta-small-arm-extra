FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI = "file://xorg.conf"
