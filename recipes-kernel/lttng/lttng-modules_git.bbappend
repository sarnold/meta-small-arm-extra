SRCREV = "a310ebbc1dab9257dbcda48004ceea3bbaed037c"
PV = "2.7.4+git${SRCPV}"
