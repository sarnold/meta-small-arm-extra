include cups-filters.inc

#SRC_URI = "https://github.com/Distrotech/${PN}/archive/release-1-5-0.tar.gz"
SRC_URI[md5sum] = "9ecda355e1f4c781784f902737df6321"
SRC_URI[sha256sum] = "0ad46d15737b309fe648fe39023a4eb6a3528faadbeb97d6ecf523df40950033"
