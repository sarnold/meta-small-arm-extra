FILESEXTRAPATHS:prepend := "${THISDIR}/files/:"

SRC_URI:append = "file://0001-qemu-do-not-define-struct-sched_attr.patch"
